<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/DY_BLE_CTRL.ewp</path>
  </project>
  <batchBuild/>
</workspace>

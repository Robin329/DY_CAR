# IAR project DY_Sonar_Timer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432E401Y TexasInstruments MSP432E401Y
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -I$PROJ_DIR$; -I$SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source; -I$SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/CMSIS/Include; -DDeviceFamily_MSP432E4; -D__MSP432E401Y__; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.PreInclude: C:\ti\simplelink_msp432e4_sdk_2_10_00_17\source\ti\devices\msp432e4\inc\msp432e401y.h
  ICCARM.CCIncludePath2: C:\ti\simplelink_msp432e4_sdk_2_10_00_17\source\ti\devices\msp432e4\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DeviceFamily_MSP432E4; __MSP432E401Y__
  AARM.AUserIncludes: $PROJ_DIR$; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/CMSIS/Include
  OBJCOPY.OOCOutputFile: DY_Sonar_Timer.srec
  ILINK.IlinkOutputFile: DY_Sonar_Timer.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_msp432e401y.icf
  ILINK.IlinkExtraOptions: $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4f; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4f/grlib.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m4f/spiffs.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_msp432e4.arm4f; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/fatfs/lib/iar/m4f/fatfs.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/devices/msp432e4/driverlib/lib/iar/m4f/msp432e4_driverlib.a; --silent; --cpu=Cortex-M4F; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group DY_Sonar_Timer/Source files
    ./: DY_Sonar_Timer_msp432e401y.icf main.c Sonar.c Sonar.h system_msp432e401y.c
    iar/: startup_msp432e401y_ewarm.c
